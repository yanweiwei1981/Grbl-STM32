# Keil uVision project Project.uvproj, settings and files
target USART_GRBL-v9.0 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: USART_GRBL +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\CMSIS\DeviceSupport\Startup;..\Libraries\STM32F10x_StdPeriph_Driver_v3.5\inc;..\Libraries\STM32F10x_StdPeriph_Driver_v3.5\src;..\User\Main;..\SYSTEM;..\HARDWARE;..\GRBL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User/Main
    ../User/Main/: hw_config.c main.c stm32f10x_it.c
  group Libraries/StdPeriph_Driver_v3.5
    ../Libraries/STM32F10x_StdPeriph_Driver_v3.5/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_tim.c
  group Libraries/CMSIS
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
    ../Libraries/CMSIS/DeviceSupport/Startup/: startup_stm32f10x_cl.s
  group Doc
    ../Doc/: information.txt
  group GRBL_09j
    ../GRBL/: coolant_control.c eeprom.c gcode.c limits.c motion_control.c nuts_bolts.c planner.c print.c probe.c protocol.c report.c serial.c settings.c spindle_control.c stepper.c system.c
  group SYSTEM
    ../SYSTEM/: bit.c strprintf.c sys.c delay.c simuspi.c simui2c.c
  group HARDWARE
    ../HARDWARE/: HW_EEPROM.c HW_EXTI.c HW_GPIO.c HW_PWM.c HW_TIM.c HW_USART.c
